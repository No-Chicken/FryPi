# Keil uVision project NN_Test.uvprojx, settings and files
target NN_Test (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: NN_Test +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE
  c include: ../Core/Inc;../X-CUBE-AI/App;../X-CUBE-AI;../Middlewares/ST/AI/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../X-CUBE-AI/Target
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: NN_Test.sct
  group Application/MDK-ARM
    ./: startup_stm32f411xe.s
  group Application/User/X-CUBE-AI/App
    ../X-CUBE-AI/App/: sine_calcu.c sine_calcu_data.c sine_calcu_data_params.c aiSystemPerformance.c aiTestHelper.c aiTestUtility.c ai_device_adaptor.c lc_print.c syscalls.c app_x-cube-ai.c
  group Application/User/Core
    ../Core/Src/: main.c gpio.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Doc
    ../X-CUBE-AI/App/: sine_calcu_generate_report.txt
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Lib
    ../Middlewares/ST/AI/Lib/: NetworkRuntime1010_CM4_Keil.lib
software components: CMSIS:CORE 4.3.0
